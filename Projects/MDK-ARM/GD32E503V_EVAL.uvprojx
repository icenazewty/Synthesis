# Keil uVision project GD32E503V_EVAL.uvprojx, settings and files
target GD32E503 (6160000::V6.16::ARMCLANG)
  device: GD32E503VE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: SysCtrl_V11_GD32E503VCT6 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output Output/SysCtrl_V11_GD32E503VCT6.bin Output/SysCtrl_V11_GD32E503VCT6.axf
  AfterMake: ../BOOT_CRC32.exe   output/SysCtrl_V11_GD32E503VCT6.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32E50X GD32E50X_HD
  c include: ..\inc;..\..\Utilities;..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\class\device\cdc\Include;..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\device\Include;..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\usbd\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM33_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Appliction
    ../src/: main.c gd32e50x_it.c gd32e50x_usbd_hw.c systick.c W5500.c cfg_flash.c wifi_ble.c spi_flash.c ads1247.c comm_process.c AD_process.c can_bus.c gprs.c usb_para.c snmplib.c snmpdemo.c sht3x.c i2c_hal.c ch432t.c rtc_user.c datetime_user.c MQTT.c
    ../../Utilities/: FreeRTOSConfig.h
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_dma.c gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_exti.c gd32e50x_can.c gd32e50x_dbg.c gd32e50x_spi.c gd32e50x_fwdgt.c gd32e50x_adc.c gd32e50x_rtc.c gd32e50x_bkp.c
  group GD32E50x_EVAL
    ../../Utilities/: gd32e503v_eval.c GlobalVar.c
  group Startup
    ../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group USBD_Drivers
    ../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
  group Doc
    ../: readme.txt
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM33_NTZ/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.5.0
